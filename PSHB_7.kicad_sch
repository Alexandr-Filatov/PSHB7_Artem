File: PSHB_7.kicad_sch (KiCad schematic)
At the start: 14 parts

Commit message: Поменял десат подключение, сделал зазоры на силовых полигонах
Parts:
- D16, D43: value ~ -> (none)
