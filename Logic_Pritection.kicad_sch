File: Logic_Pritection.kicad_sch (KiCad schematic)
At the start: 16 parts

Commit message: Поменял десат подключение, сделал зазоры на силовых полигонах
Parts:
- D2, D3: value ~ -> (none)
