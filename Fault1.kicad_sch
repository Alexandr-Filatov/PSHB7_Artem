File: Fault1.kicad_sch (KiCad schematic)
At the start: 15 parts

Commit message: Поменял десат подключение, сделал зазоры на силовых полигонах
Parts:
- D1, D12, D13, D19, D5: value ~ -> (none)
